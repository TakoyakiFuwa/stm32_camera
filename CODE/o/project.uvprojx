# Keil uVision project project.uvprojx, settings and files
target Target_1 (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F429VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c misc: --diag-suppress=870
  c include: ..\st_core;..\st_lib;..\os_src;..\main;..\library;..\o;..\fatfs;..\tft;..\camera;..\ui
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group st_core
    ../st_core/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h misc.c misc.h stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h
  group st_lib
    ../st_lib/: stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_cec.c stm32f4xx_cec.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dfsdm.c stm32f4xx_dfsdm.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dma2d.c stm32f4xx_dma2d.h stm32f4xx_dsi.c stm32f4xx_dsi.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.c stm32f4xx_fmpi2c.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_lptim.c stm32f4xx_lptim.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_qspi.c stm32f4xx_qspi.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sai.c stm32f4xx_sai.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spdifrx.c stm32f4xx_spdifrx.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group os_src
    ../os_src/: FreeRTOS.h task.h atomic.h croutine.c croutine.h deprecated_definitions.h event_groups.c event_groups.h heap_4.c list.c list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h port.c portable.h projdefs.h queue.c queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.c stream_buffer.h tasks.c timers.c timers.h portmacro.h
  group fatfs
    ../fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c sdio_sd.c sdio_sd.h
  group library
    ../library/: U_USART.c U_USART.h M_ADC.c M_ADC.h Botton.c Botton.h ButtonFunc.c ButtonFunc.h
  group main
    ../main/: main.c Shadow.c Func.c Func.h startup_stm32f40_41xxx.s FreeRTOSConfig.h BaseFunc.c BaseFunc.h Shadow.h cmr_def.h
  group tft
    ../tft/: font.c TFT_ST7789V.c TFT_ST7789V.h bmp.c bmp.h
  group camera
    ../camera/: ov7670.c ov7670.h
  group ui
    ../ui/: UI_Core.c UI_Core.h UI_Instance.c UI_Instance.h UI_Render.c UI_Render.h
